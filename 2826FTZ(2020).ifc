Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-08T15:32:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 08 15:32:55 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{8D9F6AA4-9D07-4811-895D-8B0E52072C77}\ifc * Database version: 5507 * Database creation date: Wed Apr 08 15:32:53 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 08 15:32:54 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 08 15:32:54 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 2826FTZ Washbasin faucet, 9/12 V, Bluetooth, 2826FTZ(2020):2826FTZ Washbasin faucet, 9/12 V, Bluetooth:336544
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 163.5 mm; FaucetNominalHeight: 147 mm; FaucetNominalWidth: 60 mm; HandShowerNominalDepth: 64 mm; HandShowerNominalHeight: 286.2 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm; Projection: 115 mm
Type - Electrical(Type) - Bluetooth: 4.x; Electrical Connection: 230 / 9 V; Electronic Parts: Autofocus sensor;Solenoid valve;; Operating Voltage: 12 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 2826FTZ(2020); ConvergoRefNr: 0087-2003-0009-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 02/04/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: HC; Customs Code: 84818011; EAN Number: 6414150096006; EMC Directive: 2014/30/EU; EN Standard: EN 15091; LVI Number: 6110293; Noise Class: I (ISO 3822); RSK Number: 8430608; VVS Number: 704259504
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/2826FTZ; Catalog Drawing URL: http://static.oras.com/catdrw/2826FTZ; Class: Touchless;Bluetooth®;Plug transformer;Bidetta; Dimension Drawing URL: http://static.oras.com/dimdrw/2826FTZ; FDV Document URL: http://www.oras.com/datasheet/2826FTZ/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2826FTZ; Group: Washbasin faucets; Long Marketing: Washbasin faucet with Bidetta hand shower. Fixed spout and aerator. Shower hose 1.75 m, wall bracket. There are also in-built limitation options for water temperature and maximum flow-rate.; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;POL;RUS;SWE;UKR; Model: 2826FTZ Washbasin faucet, 9/12 V, Bluetooth; Name_en: 2826FTZ Washbasin faucet, 9/12 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 520 x 215 x 70; Package Weight: 2.546 kg; Product Code: 2826FTZ; Product Datasheet: http://www.oras.com/datasheet/2826FTZ/en; Product Family: Oras Cubista; Product Image URL: http://static.oras.com/image/2826FTZ; Product URL: http://static.oras.com/2826FTZ; Type Name: 2826FTZ Washbasin faucet, 9/12 V, Bluetooth
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (via bluetooth); Aerator: CASCADE®; Afterflow Period: 3; Automatic Flush: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Connection: Flexible Inlet Pipes; Connection Size: G3/8; DN Size: DN15; Flow: Limitation option for maximum flow-rate; Flow Rate At 300kPa: 0.00353147 m3/s; Hand Shower: Bidetta hand shower; Installation and Maintenance: http://static.oras.com/manual/2826FTZ; Installation Type: Deck mounted; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mechanical Parts: Mixing valve;Non-return valve(s);Litter filter(s); Mounting Holes: 1 Mounting Hole; Pressure Loss With Flow 01ls: 250000 Pa; Protection Class: IP 55 / transformer IP 20; Shower Parts: Shower holder;Shower Hose (1500 mm); Spare Parts: http://static.oras.com/sp/2826FTZ; Spout Type: Fixed spout; Temperature: Temperature limiter (retrofittable)
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2826FTZ(2020); Features: Touchless;Bluetooth®;Plug transformer;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2826FTZ; Name: 2826FTZ Washbasin faucet, 9/12 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:60x165x145 mm / Hand shower: 45x65x285 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2826FTZ; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2826FTZ Washbasin faucet, 9/12 V, Bluetooth
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0808206 m2; Volume: 0.00249297 m3
Identity Data - Mark: 9
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 2826FTZ(2020): 2826FTZ Washbasin faucet, 9/12 V, Bluetooth; Family and Type: 2826FTZ(2020): 2826FTZ Washbasin faucet, 9/12 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2826FTZ(2020): 2826FTZ Washbasin faucet, 9/12 V, Bluetooth; Type Id: 2826FTZ(2020): 2826FTZ Washbasin faucet, 9/12 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
